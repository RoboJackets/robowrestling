# Repository RoboJackets/robowrestling (continued)

## KiCad design 3kg/Ferrarii-2026/Control_Board/Control_Board.kicad_pcb (continued)

Board: 2 copper layers, 174.0 x 109.0 mm, 94 parts (11 on the bottom side), 71 nets.

## KiCad design juan-shi/juan-shi.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C3, C4, C5, C6, C7: 10uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D8: LED; LED_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm
J1, J2, J3, J4, J13: Screw3; PinHeader_1x03_P2.54mm_Vertical
J5, J10: Screw_Terminal_01x02; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J6, J9: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J7, J8: Screw3; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
J12: xt30; AMASS_XT30U-F_1x02_P5.0mm_Vertical
PS1: P78E05-1000; TO-220-3_Horizontal_TabDown
R1, R2, R3, R4, R5, R8, R9: R_US; R_0603_1608Metric
R6, R10: 1k; R_0603_1608Metric
SW2: SW_DPDT_x2; PinHeader_1x03_P2.54mm_Vertical
SW3: SW_DIP_x02; SW_DIP_SPSTx02_Slide_6.7x6.64mm_W6.73mm_P2.54mm_LowProfile_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
U1, U3: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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

Connections:
5v: A1.27 (+5V), C4.1, J1.3, J2.3, J3.3, J4.3, J6.2, J9.3, J13.3, PS1.3 (+VOUT/GND), SW3.1, SW3.2
+3.3V: A1.17 (3V3), J7.3, J8.3
+12V: C1.1, C3.1, C5.1, C6.1, C7.1, PS1.1 (+VIN), SW2.1 (A), U1.5 (VM), U3.5 (VM)
DIP1: A1.25 (A6), R6.2, SW3.3
DIP2: A1.26 (A7), R10.2, SW3.4
GND: A1.4 (GND), A1.29 (GND), C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D8.1 (K), J1.2, J2.2, J3.2, J4.2, J6.3, J7.2, J8.2, J9.2, J12.1, J13.2, PS1.2 (GND/-VOUT), R5.2, R8.2, U1.1 (GND), U1.7 (GND), U1.9 (GND), U3.1 (GND), U3.7 (GND), U3.9 (GND)
LN1: A1.19 (A0), J7.1
LN2: A1.20 (A1), J8.1
Led1: A1.21 (A2)
MOTOR1A: A1.6 (D3), U3.3 (IN1)
MOTOR1B: A1.8 (D5), U3.2 (IN2)
MOTOR2A: A1.9 (D6), U1.3 (IN1)
MOTOR2B: A1.14 (D11), U1.2 (IN2)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R9.2
unnamed: D6.2 (A), R6.1
unnamed: D8.2 (A), R10.1
unnamed: J5.1, U3.6 (OUT1)
unnamed: J5.2, U3.8 (OUT2)
unnamed: J10.1, U1.6 (OUT1)
unnamed: J10.2, U1.8 (OUT2)
unnamed: J12.2, SW2.2 (B)
unnamed: R8.1, U1.4 (ILIM)
unnamed: R5.1, U3.4 (ILIM)
S1: A1.5 (D2), J1.1, R1.1
S2: A1.7 (D4), J3.1, R2.1
S3: A1.10 (D7), J2.1, R3.1
S4: A1.11 (D8), J4.1, R4.1
S5: A1.15 (D12), J13.1, R9.1
SCL: A1.24 (A5)
SDA: A1.23 (A4)
ST: A1.13 (D10), J9.1
Servo: A1.12 (D9), J6.1

Notes on the sheet:
Nano
Dipswitch
LEDs
Pin Headers

Board: 2 copper layers, 63.4 x 35.0 mm, 45 parts (17 on the bottom side), 33 nets.

Other parts of the board:
H4#2: MountingHole; MountingHole_2.5mm

## KiCad design RCReceiver/RCReceiver.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C2, C3, C4: C; C_1206_3216Metric
D1: LED; LED_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm
J1, J3: Screw_Terminal_01x02; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J2: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
R1: 1k; R_1206_3216Metric
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: LD1117S12TR_SOT223; TO-220-3_Vertical
U2: NRF24L01_Breakout; nRF24L01_Breakout
U3: ROB-14450; sparkfun; PARTREV 11-13-17

Connections:
+3.3V: C3.1, C4.1, U1.2 (VO), U2.2 (VCC)
+5V: A1.27 (+5V), R1.1, U3.2 (VCC), U3.13 (STBY)
+12V: A1.30 (VIN), C2.1, SW1.1 (A), U1.3 (VI), U3.1 (VM)
CE: A1.10 (D7), U2.3 (CE)
CSN: A1.11 (D8), U2.4 (~CSN)
GND: A1.4 (GND), A1.29 (GND), C2.2, C3.2, C4.2, D1.1 (K), J2.1, U1.1 (GND), U2.1 (GND), U3.3 (GND), U3.8 (GND), U3.9 (GND)
MISO: A1.15 (D12), U2.7 (MISO)
MOSI: A1.14 (D11), U2.6 (MOSI)
Motor1A: A1.19 (A0), U3.14 (AI1)
Motor1B: A1.20 (A1), U3.15 (AI2)
Motor2A: A1.21 (A2), U3.11 (BI2)
Motor2B: A1.22 (A3), U3.12 (BI1)
unnamed: D1.2 (A), R1.2
unnamed: J1.1, U3.4 (A01)
unnamed: J1.2, U3.5 (A02)
unnamed: J2.2, SW1.2 (B)
unnamed: J3.1, U3.7 (B01)
unnamed: J3.2, U3.6 (B02)
PWMA: A1.6 (D3), U3.16 (PWMA)
PWMB: A1.8 (D5), U3.10 (PWMB)
SCK: A1.16 (D13), U2.5 (SCK)

Board: 2 copper layers, 87.8 x 49.9 mm, 16 parts (0 on the bottom side), 21 nets.

## KiCad design RCController/RCController.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C3, C4, C5: C; C_1206_3216Metric
D1: LED; LED_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm
J1: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J2, J4: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
R1: 1k; R_1206_3216Metric
SW1: SW_SPDT; PinHeader_1x03_P2.54mm_Vertical
U1: NRF24L01_Breakout; nRF24L01_Breakout
U2: LD1117S12TR_SOT223; TO-220-3_Vertical

Connections:
+3.3V: C1.1, C4.1, U1.2 (VCC), U2.2 (VO); also elsewhere on the board
+5V: A1.27 (+5V), J2.4, J4.4, R1.1
+12V: A1.30 (VIN), C3.1, C5.1, SW1.1 (A), U2.3 (VI)
CE: A1.10 (D7), U1.3 (CE)
CSN: A1.11 (D8), U1.4 (~CSN)
GND: A1.4 (GND), A1.29 (GND), C1.2, C3.2, C4.2, C5.2, D1.1 (K), J1.1, J2.5, J4.5, U1.1 (GND), U2.1 (GND); also elsewhere on the board
Joy1X: A1.19 (A0), J2.3
Joy1Y: A1.20 (A1), J2.2
Joy2X: A1.21 (A2), J4.3
Joy2Y: A1.22 (A3), J4.2
MISO: A1.15 (D12), U1.7 (MISO)
MOSI: A1.14 (D11), U1.6 (MOSI)
unnamed: D1.2 (A), R1.2
unnamed: J1.2, SW1.2 (B)
SCK: A1.16 (D13), U1.5 (SCK)

Board: 2 copper layers, 145.8 x 55.4 mm, 17 parts (0 on the bottom side), 15 nets.

Other parts of the board:
C2: C; C_1206_3216Metric

Their connections:
+3.3V: C2.1; also elsewhere on the board
GND: C2.2; also elsewhere on the board

## KiCad design 3kg/Strawberri/Strawberri/Strawberri.kicad_pcb

Board: 2 copper layers, 170.0 x 35.0 mm, 54 parts (16 on the bottom side), 40 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7: .1 µF; C_0805_2012Metric
C11, C19, C20, C21, C22: 10 µF; C_0805_2012Metric
C14: 10uF; C_0805_2012Metric
C16: 10 uF; C_0805_2012Metric
F1: Fuse; Fuse_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J2: Screw_Terminal_01x04; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J3: Screw_Terminal_01x06; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J7: Battery; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J9: Conn_01x03; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J15: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Vertical
J17, J18, J19, J20: Screw_Terminal_01x03; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
R1, R3, R5, R7, R9, R11, R13: 27000; R_0805_2012Metric
R2, R4, R6, R8, R10, R12, R14: 10000; R_0805_2012Metric
SW1: SW_SPDT; switch
SW2: SW_DIP_x03; 219-3LPSTR
U1: DEV-16771; MODULE_DEV-16771
U9: R-78K5.0-0.5 (vr 5v); CONV_TSR_1-2450
om1, om2, om3, om4, om5, om6, om7: Screw_Terminal_01x03; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
start1: .1 uF; C_0805_2012Metric

Connections:
+3.3V: J9.2, U1.3.3V_1 (3.3V), U1.3.3V_2 (3.3V), start1.2
+5V: C11.2, C16.1, C19.2, C20.2, C21.2, C22.2, J2.4, J3.1, J15.9, J17.2, J18.2, J19.2, J20.2, SW2.1, SW2.2, SW2.3, U1.VIN, U9.3 (+VOUT)
+12V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C14.1, F1.2, U9.1 (+VIN), om1.1, om2.1, om3.1, om4.1, om5.1, om6.1, om7.1
BDC1: J15.5, U1.11 (MOSI)
BDC2: J15.4, U1.37 (CS3)
BDC11: J15.3, U1.12 (MISO)
BDC22: J15.6, U1.36 (CS2)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C11.1, C14.2, C16.2, C19.1, C20.1, C21.1, C22.1, J2.1, J3.2, J7.1, J9.3, J15.1, J17.1, J18.1, J19.1, J20.1, R2.2, R4.2, R6.2, R8.2, R10.2, R12.2, R14.2, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U9.2 (GND), om1.2, om2.2, om3.2, om4.2, om5.2, om6.2, om7.2, start1.1
unnamed: J7.2, SW1.2 (B)
unnamed: F1.1, SW1.1 (A)
unnamed: R1.1, om1.3
unnamed: R3.1, om2.3
unnamed: R5.1, om3.3
unnamed: R7.1, om4.3
unnamed: R9.1, om5.3
unnamed: R11.1, om6.3
unnamed: R13.1, om7.3
OM1: R1.2, R2.1, U1.23 (A9)
OM2: R3.2, R4.1, U1.22 (A8)
OM3: R5.2, R6.1, U1.0 (RX1)
OM4: R7.2, R8.1, U1.3 (LRCLK2)
OM5: R9.2, R10.1, U1.33 (MCLK2)
OM6: R11.2, R12.1, U1.34 (RX8)
OM7: R13.2, R14.1, U1.32 (OUT1B)
PWMA: J15.7, U1.27 (A13)
PWMB: J15.8, U1.28 (RX7)
ado: J3.5, U1.39 (A15)
int: J3.6, U1.38 (A14)
l1: J17.3, U1.26 (A12)
l2: J18.3, U1.1 (TX1)
l3: J19.3, U1.2 (OUT2)
l4: J20.3, U1.8 (TX2)
receiver: J2.3, U1.25 (A11)
scl: J3.3, U1.41 (A17)
sda: J3.4, U1.40 (A16)
start: J9.1, U1.10 (CS1)
switch1: SW2.6, U1.21 (A7)
switch2: SW2.5, U1.20 (A6)
switch3: SW2.4, U1.19 (A5)
transmitter: J2.2, U1.24 (A10)

## Commit log (part)

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2023-11-17 i tried
2023-12-01 Added Start Module
2023-12-01 Change names
2023-12-01 Yellow
2023-12-01 changed schematic
2024-01-19 inserted frosti files in 500g
2024-01-19 testing
2024-01-19 voltage regulator and battery
2024-01-19 pcb layout done
2024-01-21 Fixed motor driver
2024-01-23 cleanup schematic
2024-01-23 finally found the 6V regulator
2024-01-24 Added the 6V voltage Regulator
2024-01-24 just playing around
2024-01-25 errors?
2024-01-25 changed bunch of schematics to passive
2024-01-25 tried again
2024-01-26 Update 1/25/24
2024-01-26 Chnged voltrage regulator
2024-01-28 Fixed ERC Errors
2024-01-28 epic presentation and decoupling
2024-01-28 started matching footprints
2024-01-28 jojo
2024-01-28 testing commits
2024-01-28 deteled Teddi folder, added Franki folder
2024-01-28 footprint
2024-02-01 parts list and schemaitc reviewed'
2024-02-02 Ready to print Board - Teddi :100:
    This is our final board with gerber files. Thanks!
2024-02-02 Schematic Screenshot
2024-02-02 realized i was making screw terminals the whole time
2024-02-02 wonderous footprint assignments
2024-02-02 footprints have been made
2024-02-04 layout work
2024-02-07 i d k
2024-02-09 didn't realize it wasnt a screw terminal
2024-02-11 more layout work
2024-02-11 PCB Layout finished
2024-02-11 layouut5
2024-02-11 Teddi 2-11-24
2024-02-11 pcb finished
2024-02-11 clutched up finish on the pcb
2024-02-16 NEW Motordriver!
2024-02-17 Final pcb design
2024-02-18 Timmi cb
2024-02-18 Create Frankii files
2024-02-18 Create aasdf
2024-02-18 Create asdf
2024-02-18 Added battery connection stuff and chose BMI323 as IMU
2024-02-23 added voltage regulators to timmi cb
2024-02-26 added power switch circuit
2024-03-03 wired imu and added ir indicators
2024-03-08 imu int pins
2024-05-23 added load switch values
2024-05-23 added load switch resistor vals
2024-06-06 first
2024-06-07 Create cad
2024-06-12 joes magic
2024-06-13 hbridge?
2024-06-14 stuff
2024-06-27 motor driver
2024-06-28 schematic is pretty muchdone
2024-07-11 added foortprints
2024-07-18 finished fooorptinrt
2024-08-02 sum motor driver stuff
2024-08-20 finished motordriver layout
2024-08-20 Layout Progress
2024-08-20 progress on layout
2024-08-20 finish motor driver
2024-08-25 mode select
2024-08-29 more stuff
2024-08-29 added team 2
2024-09-06 added bigass capcacitor
2024-09-20 fixing footpriints
2024-09-20 added motor driver schematic
2024-09-20 differentiated between motor drivers
2024-09-20 added power
2024-09-20 updated footprints
2024-09-20 layuot work
2024-09-22 almost done with layout idk bout the level shifter though
2024-09-22 joNG
2024-09-22 layout
2024-09-22 Finished Layout Draft
2024-09-22 layout done
2024-09-22 Create test 123.txt
    isabelli test
2024-09-22 motor driver shhrinking
2024-09-22 adding monki project
    yes
2024-09-22 name change from try 2 to electrical
2024-09-22 Revert "name change from try 2 to electrical"
    This reverts commit 4b0ac75f3448ba7783e69cfdcc4d947f7fd3a45a.
2024-09-23 almostdone
2024-09-23 finished layout
2024-09-27 added pcb
2024-09-27 wired pcb
2024-09-27 fixed weird wire
2024-09-27 ig im done
2024-09-27 finished?
2024-09-27 erm what the sigma
2024-09-28 erm what the skibidi
2024-09-28 sigma moves
2024-09-28 i feel so skibidi rn
2024-09-28 skibidi rizz
2024-09-28 power board done
2024-09-28 skibidi power
2024-09-29 added some footprints
2024-10-03 joejoe
2024-10-03 pushsuskibnbiid
2024-10-04 added platio files
2024-10-04 Better directory usage
2024-10-04 fanum taxed
    fixed connection issue + added label
2024-10-04 push tuah
    finished labeling control board
2024-10-04 joe skibidi deez nus
2024-10-04 sigma fanum
2024-10-04 Ultimate pCB
2024-10-05 done
2024-10-05 pooki done
2024-10-06 done with pooki
2024-10-06 done with contrl board
2024-10-06 i thiknk its done
2024-10-06 Added Logo
2024-10-06 joehjoe
2024-10-07 10/06_Peter
2024-10-07 nond
2024-10-08 grhrsggfsfsgn
2024-10-08 idk anymore
2024-10-09 vdfdfvdf
2024-10-13 10/13_Isabelli
2024-10-17 Added screw holes on control board
2024-10-20 10/17_Peter
2024-10-20 10/20__Peter
2024-10-20 10/20_Peter.updated
2024-10-20 10/20_version3
2024-10-27 its done finallyu
2024-10-28 Added KiCAD stuff
    pcb and sch
2024-10-28 adding new motor driver
2024-10-29 10-27
2024-10-29 Isabelli_10-29
2024-10-30 10-30
2024-10-30 just deleting some extra files (ignore)
2024-10-31 started new
2024-10-31 create basic project files
2024-10-31 rename project files
2024-11-01 skbidi
2024-11-01 during meeting
2024-11-01 started new pcb
2024-11-03 think its done
2024-11-03 erfgfe
2024-11-13 Updated Rata2i schematic
    Now with more stuff! And 1 (one) LED
2024-11-15 Updated Rata2i (thrilling sequel)
2024-11-15 Add electircal schematic
2024-11-16 idk changes
2024-11-22 Cool Schematic, Some Footprints
    thanks kyle and joe
2024-12-19 some final changese
2024-12-29 ferrarii schematic added, still need to reassign pins for convenience
2024-12-29 bruh
2025-01-01 schematic is done
2025-01-05 added footprints to ferrarii
2025-01-05 updated pcb from schematic, transferring files from laptop to pc
2025-01-06 ferrarii stuff placed, not wired
2025-01-17 Update Zesti
2025-01-26 rata2i
    complete schematic yippee!! pcb not so complete
2025-01-30 PCB extravaganza
    pcb update
2025-01-31 finially
2025-01-31 new thingy
2025-01-31 cleaning up for you guys
2025-02-02 pcb??
    did we do it guys
2025-02-02 PCB!!!!!
    dont worry about the 2 errors its done
2025-02-07 Surprise in graphics
2025-02-07 final board 02/06
2025-02-08 made a whole new pcb for voltage divider
2025-02-09 skibidi 2.0 done
2025-02-09 done???????
    yeah
2025-02-09 done!!
    no more drawings i pinky promise nonemore
2025-02-09 pcb (actual) (done)
    yippeee
2025-02-10 joei projec make
2025-02-11 werid ass pcb
2025-02-12 more work
2025-02-21 almost done
2025-02-21 DONE BUT IDK
2025-02-28 uwefhiqdanjkshbgvqrevfad
2025-03-13 idk maybe theres changes
2025-03-13 dicki
2025-03-17 done with joei
2025-03-19 updated ballsi
2025-03-19 added microcontroller sensors and motordriver
2025-03-22 idk what i added
2025-03-23 added mounting hole measurements
2025-03-27 finished schematic
2025-05-08 updated everything
2025-05-08 added relay switch and dipswitch to spi schematic
2025-05-18 finished v2s
2025-05-30 controller project created
2025-06-23 ferarrii schematic draft 1
2025-06-23 sorry xander this is the real draft 1
2025-06-23 updates?
2025-06-30 custom ml2s
2025-06-30 okay custom ml2s fr
2025-07-09 added footprints, fixed schematic
2025-07-14 fixed power ferarri
2025-07-15 initial pcb layout, improvements needed and no wiring and no xander waifu
2025-07-22 pcb layout and wiring is done! still need to add silkscreen and xander waifu
2025-07-27 ml2 push for xandie wandie
2025-07-29 custom ml2 update for xandie wandie, moved resistors to same side as sensor and removed notches from screw hole
2025-07-30 added necessary silkscreen to control pcb, still need to put the less necessary silkscreen
2025-08-04 i think ferarrii pcb is done
2025-08-04 added gerbs ferarrii
2025-08-04 okay second try gerbs ferarrii
2025-08-04 okay 3rd tiems a charm ferarrii gerbs
2025-08-17 Simple_Controller using STM32 development board done
2025-08-17 Braiden-Main_Controller update w/ STM32F103C8T6
    Not the breakout STM32, but the bare chip was utilized for this schematic
2025-08-18 Braiden Anderson - Basic_Main_Controller
2025-08-18 Fixed issues with Simple_Controller
2025-08-18 backing up
2025-08-18 Braiden-Complex_Controller
2025-08-19 Braiden-Basic & Complex Board upload
2025-08-19 Braiden - Basic_Controller Update b/c Phys. Interference
2025-08-19 Braiden - Update Complex_Controller w/ Signature
2025-08-21 custom ml2 gerbers generated
2025-08-31 Create ReadMe
    readme added <333333
2025-08-31 strawberri kicad
    made strawberri kicad beginning
2025-09-02 changing monki to giovanni
2025-09-02 giovanni
2025-09-04 giovanni motor test code
2025-09-07 Made stm board
2025-09-08 changed kicad shematic
    wowowoowwo this is so great there is zero problem (just added two sensors on schematic and the switch)
2025-09-14 basically just fixed all the copy issue
2025-09-21 updated rata2i schematic
    blah blah blah
2025-09-21 updated rata2i again
    asdf
2025-09-21 IT WORKS!!!!!
    yippee
2025-09-21 All parts done!
    Need to wire :(
2025-09-24 skibidi
2025-09-28 kitti schematics
2025-09-28 updated schematics
2025-09-28 added IR to schematic
2025-09-28 updating IR
2025-09-28 2 motor drivers, 2 less sensors :D
    mostly connected but it REALLY doesn't like the motor drivers, maybe moving to the normal side will make it better?
2025-09-29 motor driver and labels
2025-10-01 connected NRF
2025-10-02 added new spi board schematic changes
2025-10-02 added all feet
2025-10-02 added mor
2025-10-02 made some pcb
2025-10-02 added spi and more pcb progress
2025-10-02 added some gerbs
2025-10-02 added slippi
2025-10-02 replaced slippi
2025-10-02 updated fill zone
2025-10-02 removed DS_STORE
2025-10-02 idfk
2025-10-02 added everything??
2025-10-02 updated Slippi
2025-10-02 Slippi Update
2025-10-03 bobbi
2025-10-04 updated sensors
2025-10-04 connected everything that wasn't connected
    please someone check if this is sussy
2025-10-05 finishing touches
2025-10-05 Luigi is here
2025-10-05 Fixed the switches
2025-10-05 new celebi
2025-10-05 Changed motor driver pins
    mdr1 - 28
    mdr2 - 29
    mdr3 - 18
    mdr4 - 22
2025-10-10 Starting over rata2i!
    added the 4th line sensor in and started placing some things >_<
2025-10-12 celebi's changes
2025-10-12 Redid rata2i
    drc hates me
2025-10-12 resistor and motor driver
2025-10-14 updated 500g
2025-10-17 ONE ERROR REMAINS...
    RAHGHHHHHHHH
2025-10-21 Last error fixed
2025-10-26 Working on making power traces lorge
2025-10-26 Finished making power traces lorge
    sequel
2025-10-30 changed voltage regulator footprint
    so this is what we forgot to change from last year -_-
2025-11-20 rawr
2025-11-21 yippi start
    it begins...
2025-11-21 yippi update
    added most of the parts
    need to change to jst stuff
2025-11-23 look it's great
2025-12-13 kitti
2025-12-20 saving whatever this is
2026-01-14 started highway
2026-01-14 added new spi boards
2026-01-17 finished spi top board
2026-01-18 reorganized schematic
    TODO:
    - add servos
    - change to jst
    - add imu
    - react to joes messages
2026-01-18 parts added
    to do:
    switch to jsts
    double check number of sensors
    add labels to microcontroller
    where tf is the motor driver datasheet???
    figure out capacitor values
2026-01-19 Temporarii PCB version 2
    Second Iteration of Temporarii's pcb design with more features; sensor leds, dip switch, imu, new design
2026-01-23 did some todos
    yeah
2026-01-27 Kitti to Strawberri
2026-01-29 updates to Kitti->strawberri PCB scheme
2026-01-30 asdfadsfsa
2026-01-30 Wooh! Schm Done
2026-02-01 0 errors
    doesnt have servos
2026-02-08 gonna mess with this
    this is a version that has 0 errors
2026-02-13 hihihihhi
2026-02-15 finished and ordered
2026-02-15 initialized pcbz
2026-02-15 layout and wiring done!!! check and add details. I'm so Tired.
2026-02-15 wiring fix. Please Check it Out.
2026-02-15 fixed some errors and made 12v wider
2026-02-20 implemented entire floor pcb
2026-02-21 finished left
2026-02-22 hi
    hi
2026-02-22 ctrl board sensors, screen, start module schematic
2026-02-26 added edge cuts
2026-02-26 eewffwe
2026-02-27 new dxf (screw holes) for pcb edge cuts
2026-02-27 added some stuff
2026-02-27 basic routing, gnd planes
2026-02-27 changed some things
2026-02-28 main routing and updates
2026-03-01 added holes fixed small issues
2026-03-01 final wiring, silkscreen callouts, test points
2026-03-01 silkscreen text
2026-03-01 added buzz
2026-03-02 change 1k to 10k for LEDs
2026-03-02 review changes, pullup resistors, ulcd change
2026-03-02 rewire right signal bus
2026-03-02 flipped mtr drv
