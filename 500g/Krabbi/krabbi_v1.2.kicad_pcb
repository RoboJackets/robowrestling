# Repository RoboJackets/robowrestling

## KiCad design 500g/Krabbi/krabbi_v1.2.kicad_pcb

Board: 2 copper layers, 100.0 x 53.0 mm, 49 parts (22 on the bottom side), 41 nets.

Parts:
BT1: Battery_Cell; AMASS_XT30UPB-M_1x02_P5.0mm_Vertical
BUTTON: SW_Push; SW_PUSH_6mm_H5mm
C1, C3, C8: 0.1uF; C_0805_2012Metric
C2, C4: 100uF; CP_Radial_D6.3mm_P2.50mm
C6, C7: 10uF; C_0805_2012Metric
F1: 0154007.DR; 0154Series_LTF
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IMU1: GY-521
Q1, Q3: Q_NPN_BCE; TO-92_Inline
R1, R4, R13, R14: 4.7k; R_0805_2012Metric
R2, R3: 1k; R_0805_2012Metric
R11, R12: 220; R_0805_2012Metric
R15, R16: 16k; R_0805_2012Metric
S1: 500SSP1S2M2QEA; SW_500SSP1S2M2QEA
buck_converter: R-78E5.0-0.5; CONV_R-78E5.0-0.5
buck_converter#2: eBoot Mini MP1584EN; DC-DC BUCK CONVERTER
center_ir1: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
dip_switch: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W7.62mm_P2.54mm
frontleft_ir1: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
frontright_ir1: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
krabbi_brain: YAAJ_BlackPill; YAAJ_WeAct_BlackPill_2
l_driver: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
l_driver_wire: screw_terminal; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
led_1, led_2: LED; LED_D5.0mm
left_ir1: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
left_line_sensor1: Screw_Terminal_01x03; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
r_driver: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
r_driver_wire: screw_terminal; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
right_ir4: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
right_sensor2: Screw_Terminal_01x03; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
screen: SSD1306; 128x64OLED
servo1, servo2: Screw_Terminal_01x03; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
start: screw_terminal; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal

Connections:
3V3: IMU1.VCC, R13.1, R14.1, krabbi_brain.20 (3V3), screen.2 (VCC)
BV: C1.1, C2.1, C3.1, C4.1, C6.1, F1.1, buck_converter.1 (+VIN), buck_converter#2.1 (Vin_+), l_driver.5 (VM), r_driver.5 (VM)
GND: BT1.2 (-), BUTTON.2, C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, IMU1.GND, Q1.3 (E), Q3.3 (E), R15.1, R16.1, buck_converter.2 (GND), buck_converter#2.3 (GND), buck_converter#2.6 (GND), center_ir1.2, dip_switch.1, dip_switch.2, dip_switch.3, frontleft_ir1.2, frontright_ir1.2, krabbi_brain.19 (GND), krabbi_brain.39 (GND), l_driver.1 (GND), l_driver.7 (GND), l_driver.9 (GND), led_1.1 (K), led_2.1 (K), left_ir1.2, left_line_sensor1.1, r_driver.1 (GND), r_driver.7 (GND), r_driver.9 (GND), right_ir4.2, right_sensor2.1, screen.1 (GND), servo1.1, servo2.1, start.2
unnamed: BT1.1 (+), S1.1
unnamed: R11.1, led_1.2 (A)
unnamed: R12.1, led_2.2 (A)
unnamed: F1.2, S1.2
unnamed: Q1.1 (B), R2.2
unnamed: Q1.2 (C), R1.1, servo2.3
unnamed: Q3.1 (B), R3.2
unnamed: Q3.2 (C), R4.1, servo1.3
unnamed: R2.1, krabbi_brain.26 (PA0)
unnamed: R3.1, krabbi_brain.27 (PA1)
unnamed: dip_switch.6, krabbi_brain.1 (PB12)
unnamed: dip_switch.5, krabbi_brain.2 (PB13)
unnamed: dip_switch.4, krabbi_brain.3 (PB14)
unnamed: R15.2, l_driver.4 (ILIM)
unnamed: l_driver.6 (OUT1), l_driver_wire.1
unnamed: l_driver.8 (OUT2), l_driver_wire.2
unnamed: r_driver.6 (OUT1), r_driver_wire.1
unnamed: r_driver.8 (OUT2), r_driver_wire.2
unnamed: R16.2, r_driver.4 (ILIM)
PA2: krabbi_brain.28 (PA2), left_ir1.1
PA3: frontleft_ir1.1, krabbi_brain.29 (PA3)
PA4: center_ir1.1, krabbi_brain.30 (PA4)
PA5: frontright_ir1.1, krabbi_brain.31 (PA5)
PA6: krabbi_brain.32 (PA6), right_ir4.1
PA7: krabbi_brain.33 (PA7), left_line_sensor1.3
PA8: krabbi_brain.5 (PA8), l_driver.2 (IN2)
PA9: krabbi_brain.6 (PA9), l_driver.3 (IN1)
PB0: krabbi_brain.34 (PB0), right_sensor2.3
PB1: R12.2, krabbi_brain.35 (PB1)
PB4: BUTTON.1, krabbi_brain.12 (PB4)
PB5: R11.2, krabbi_brain.13 (PB5)
PB6: krabbi_brain.14 (PB6), r_driver.2 (IN2)
PB7: krabbi_brain.15 (PB7), r_driver.3 (IN1)
PB8: IMU1.SCL, R13.2, krabbi_brain.16 (PB8), screen.3 (SCL)
PB9: IMU1.SDA, R14.2, krabbi_brain.17 (PB9), screen.4 (SDA)
PB10: krabbi_brain.37 (PB10), start.3
heavy5V: R1.2, R4.2, buck_converter#2.8 (OUT+), servo1.2, servo2.2
logic5V: C7.1, C8.1, buck_converter.3 (+VOUT), center_ir1.3, frontleft_ir1.3, frontright_ir1.3, krabbi_brain.40 (5V), left_ir1.3, left_line_sensor1.2, right_ir4.3, right_sensor2.2, start.1

## KiCad design 500g/Luigi/Luigi.kicad_pcb

Parts:
0.1uF1, 10uF1, 10uF2: C_Small_US; C_0805_2012Metric
A1: Arduino_Nano_Every; Arduino_Nano
BT1: 12V; AMASS_XT30U-F_1x02_P5.0mm_Vertical
F1: 0154007.DR; FUSE_0154007.DR; PARTREV GD
FC_dis1: Conn_01x03_Pin; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
FL_dis1: Conn_01x03_Pin; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
FR_dis1: Conn_01x03_Pin; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J3: Motor 2; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J4: Motor 1; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
L_dis1: Conn_01x03_Pin; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
R1, R2: 21k; R_0805_2012Metric
R3, R4, R5: R_Small_US; R_0805_2012Metric
R_dis1: Conn_01x03_Pin; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
S1: 500SSP1S2M2QEA; SW_500SSP1S2M2QEA; PARTREV C
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
SW2: SW_Push; SW_PUSH_6mm_H5mm
U1, U2: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U3: L78L05_TO92; PinHeader_1x03_P2.54mm_Vertical
lineSensor1: a; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
lineSensor2: Screw_Terminal_01x03; JST_EH_B3B-EH-A_1x03_P2.50mm_Vertical
startmodule1: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical

Connections:
BV: 10uF1.1, A1.30 (VIN), F1.1, U1.5 (VM), U2.5 (VM), U3.3 (VI)
FC-dis: A1.10 (D7), FC_dis1.3
FL-dis: A1.11 (D8), FL_dis1.3
FR-dis: A1.7 (D4), FR_dis1.3
GND: 0.1uF1.2, 10uF1.2, 10uF2.2, A1.4 (GND), A1.29 (GND), BT1.1 (+), FC_dis1.2, FL_dis1.2, FR_dis1.2, L_dis1.2, R1.1, R2.1, R3.1, R4.1, R5.2, R_dis1.2, U1.1 (GND), U1.7 (GND), U1.9 (GND), U2.1 (GND), U2.7 (GND), U2.9 (GND), U3.2 (GND), lineSensor1.1, lineSensor2.1, startmodule1.2
MDRV11: A1.8 (D5), U1.3 (IN1)
MDRV12: A1.6 (D3), U1.2 (IN2)
MDRV21: A1.13 (D10), U2.3 (IN1)
MDRV22: A1.12 (D9), U2.2 (IN2)
unnamed: A1.21 (A2), lineSensor1.3
unnamed: A1.22 (A3), L_dis1.3
unnamed: A1.25 (A6), R5.1, SW2.1
unnamed: A1.26 (A7), lineSensor2.3
unnamed: A1.5 (D2), R_dis1.3
unnamed: BT1.2 (-), S1.2
unnamed: F1.2, S1.1
unnamed: J3.1, U1.6 (OUT1)
unnamed: J3.2, U1.8 (OUT2)
unnamed: J4.1, U2.6 (OUT1)
unnamed: J4.2, U2.8 (OUT2)
unnamed: R2.2, U1.4 (ILIM)
unnamed: R1.2, U2.4 (ILIM)
Reg5: 0.1uF1.1, 10uF2.1, FC_dis1.1, FL_dis1.1, FR_dis1.1, L_dis1.1, R_dis1.1, SW1.1, SW1.2, SW2.2, U3.1 (VO), lineSensor1.2, lineSensor2.2, startmodule1.3
Start: A1.9 (D6), startmodule1.1
dip13: A1.20 (A1), R3.2, SW1.3
dip14: A1.19 (A0), R4.2, SW1.4

Board: 2 copper layers, 99.0 x 40.0 mm, 31 parts (3 on the bottom side), 26 nets.

## KiCad design 500g/NewMemberBoard/500gNewMemberBoard.kicad_pcb

Parts:
C1, C5: 10uF; CP_EIA-3216-18_Kemet-A
C2, C4: 22uF; CP_EIA-3216-18_Kemet-A
C3, C6, C7, C8, C11, C14, C16: 0.1uF; C_0603_1608Metric
C9, C13, C18: 1uF; C_0603_1608Metric
C10, C12: 4.7uF; CP_EIA-3216-18_Kemet-A
C15, C17: 47uF; C_1206_3216Metric
D1: D_Schottky; D_SMP_DO-220AA
D2: TX; LED_0603_1608Metric
D3: RX; LED_0603_1608Metric
D4: SCK; LED_0603_1608Metric
D5: A0; LED_0603_1608Metric
D6: A1; LED_0603_1608Metric
D7: A2; LED_0603_1608Metric
D8: A3; LED_0603_1608Metric
D9: A4; LED_0603_1608Metric
D10: A6; LED_0603_1608Metric
D11: A7; LED_0603_1608Metric
D12: 5v; LED_0603_1608Metric
D13: 12v; LED_0603_1608Metric
D14: Button; LED_0603_1608Metric
F1: 500mA; Fuse_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB-C Connector; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: ICSP; PinHeader_2x03_P2.54mm_Vertical
J3: M1; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J4: M2; TerminalBlock_Xinya_XY308-2.54-2P_1x02_P2.54mm_Horizontal
J5, J6, J7, J8, J9, J10, J11: Conn_01x03; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J12: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J13: Conn_01x02; AMASS_XT30U-M_1x02_P5.0mm_Vertical
R1, R2: 5.1k; R_0603_1608Metric
R3, R4, R5, R6, R7, R11, R12, R13, R14, R15, R16, R17, R18, R20: 1k; R_0603_1608Metric
R8: 10k; R_0603_1608Metric
R9, R10: 18k; R_0603_1608Metric
R19: 2.4k; R_0603_1608Metric
R21: 4.7k; R_0603_1608Metric
R22: 4.7k; R_0603_1608Metric; not fitted
SW1: Reset; SW_Push_SPST_NO_Alps_SKRK
SW2: Button1; SW_PUSH_6mm
SW3: Power; SW_1101M2S3CQE2
TP1: TestPoint; 0.5mm_drill_0.85_0.85mm_test_point
U1: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U2, U6: AMS1117-5.0; SOT-223-3_TabPin2
U3: CH340X; MSOP-10_3x3mm_P0.5mm
U4, U5: DRV8871DDA; Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.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
U7: USBLC6-2P6; SOT-666
Y2: 16MHz; OSC_CSTNE16M0V530000R0

Connections:
5v: C2.1, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.3, U6.2 (VO)
+5V: C4.1, C9.1, C10.1, C13.1, C18.1, D1.1 (K), D2.2 (A), D3.2 (A), D14.2 (A), J2.2, R8.1, R18.1, U1.4 (VCC), U1.6 (VCC), U1.18 (AVCC), U2.2 (VO), U3.7 (VCC)
+12V: C1.1, C5.1, C14.1, C15.1, C16.1, C17.1, R19.1, SW3.2 (B), TP1.1, U2.3 (VI), U4.5 (VM), U5.5 (VM), U6.3 (VI)
/USBC_D+: J1.A6 (D+), J1.B6 (D+), U7.3 (I/O2)
/USBC_D-: J1.A7 (D-), J1.B7 (D-), U7.1 (I/O1)
A0: J11.1, R11.1, U1.23 (PC0)
A1: J5.1, R12.1, U1.24 (PC1)
A2: J9.1, R13.1, U1.25 (PC2)
A3: J10.1, R14.1, U1.26 (PC3)
A4: J6.1, R15.1, U1.27 (PC4)
A5: U1.28 (PC5)
A6: J8.1, R16.1, U1.19 (ADC6)
A7: J7.1, R17.1, U1.22 (ADC7)
Button1: R20.2, SW2.2, U1.11 (PD7)
D10: U1.14 (PB2)
D+: U3.1 (UD+), U7.4 (I/O2)
D-: U3.2 (UD-), U7.6 (I/O1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.6, J5.3, J6.3, J7.3, J8.3, J9.3, J10.3, J11.3, J12.2, J13.1, R1.2, R2.2, R9.2, R10.2, R22.2, SW1.1, SW2.1, U1.3 (GND), U1.5 (GND), U1.21 (GND), U2.1 (GND), U3.3 (GND), U4.1 (GND), U4.7 (GND), U4.9 (GND), U5.1 (GND), U5.7 (GND), U5.9 (GND), U6.1 (GND), U7.2 (GND), Y2.2
MISO: J2.1, U1.16 (PB4)
MOSI/D11: J2.4, U1.15 (PB3)
Motor1A: U1.1 (PD3), U4.3 (IN1)
Motor1B: U1.9 (PD5), U4.2 (IN2)
Motor2A: U1.10 (PD6), U5.3 (IN1)
Motor2B: U1.13 (PB1), U5.2 (IN2)
unnamed: D2.1 (K), R5.1
unnamed: D3.1 (K), R6.1
unnamed: D4.2 (A), R7.2
unnamed: D5.2 (A), R11.2
unnamed: D6.2 (A), R12.2
unnamed: D7.2 (A), R13.2
unnamed: D8.2 (A), R14.2
unnamed: D9.2 (A), R15.2
unnamed: D10.2 (A), R16.2
unnamed: D11.2 (A), R17.2
unnamed: D12.2 (A), R18.2
unnamed: D13.2 (A), R19.2
unnamed: D14.1 (K), R20.1
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J3.1, U4.6 (OUT1)
unnamed: J3.2, U4.8 (OUT2)
unnamed: J4.1, U5.6 (OUT1)
unnamed: J4.2, U5.8 (OUT2)
unnamed: J13.2, SW3.3 (C)
unnamed: C3.1, U1.20 (AREF)
unnamed: R3.1, U1.30 (PD0)
unnamed: R4.1, U1.31 (PD1)
unnamed: U1.7 (XTAL1/PB6), Y2.3
unnamed: U1.8 (XTAL2/PB7), Y2.1
unnamed: C8.1, R21.2, R22.1, U3.6 (TNOW/~DTR)
unnamed: C7.1, U3.10 (V3)
unnamed: R21.1, U3.5 (~CTS)
unnamed: R9.1, U4.4 (ILIM)
unnamed: R10.1, U5.4 (ILIM)
unnamed: C6.1, F1.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U7.5 (VBUS)
RESET: C8.2, J2.5, R8.2, SW1.2, U1.29 (~RESET/PC6)
RX: R3.2, R6.2, U3.8 (TXD)
SCK: J2.3, R7.1, U1.17 (PB5)
Start: J12.1, U1.2 (PD4)
TX: R4.2, R5.2, U3.9 (RXD)
VBUS: C11.1, C12.1, D1.2 (A), F1.1

Notes on the sheet:
Peripherals
Sensors
Power
Open Source DTR
Voltage Regulators
USB-C/Programming
Motors
Push-Pull DTR
LEDs/Buttons
Microcontroller
MCU

Board: 2 copper layers, 95.0 x 35.0 mm, 84 parts (0 on the bottom side), 59 nets.

File 500g/NewMemberBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C5",CP_EIA-3216-18_Kemet-A,2,10uF,C128254
"C10, C12",CP_EIA-3216-18_Kemet-A,2,4.7uF,C116616
"C11, C14, C16, C3, C6, C7, C8",0603,7,0.1uF,C14663
"C13, C18, C9",0603,3,1uF,C15849
"C15, C17",1206,2,47uF,C96123
"C2, C4",CP_EIA-3216-18_Kemet-A,2,22uF,C782264
D1,D_SMP_DO-220AA,1,D_Schottky,C2875475
D10,0603,1,A6,C2288
D11,0603,1,A7,C2288
D12,0603,1,5v,C12624
D13,0603,1,12v,C12624
D14,0603,1,Button,C2288
D2,0603,1,TX,C2287
D3,0603,1,RX,C2287
D4,0603,1,SCK,C2288
D5,0603,1,A0,C2288
D6,0603,1,A1,C2288
D7,0603,1,A2,C2288
D8,0603,1,A3,C2288
D9,0603,1,A4,C2288
F1,0603,1,500mA,C210357
J1,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,1,USB-C Connector,C3020560
"R1, R2",0603,2,5.1k,C23186
"R10, R9",0603,2,18k,C25810
"R11, R12, R13, R14, R15, R16, R17, R18, R20, R3, R4, R5, R6, R7",0603,14,1k,C21190
R19,0603,1,2.4k,C22940
R21,0603,1,4.7k,C23162
R8,0603,1,10k,C15401
SW1,SW_Push_SPST_NO_Alps_SKRK,1,Reset,C778164
U1,TQFP-32_7x7mm_P0.8mm,1,ATmega328P-A,C14877
"U2, U6",SOT-223-3_TabPin2,2,AMS1117-5.0,C6187
U3,MSOP-10_3x3mm_P0.5mm,1,CH340X,C3035748
"U4, U5",Texas_HTSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.4x3.1mm_ThermalVias,2,DRV8871DDA,C1556867
U7,SOT-666,1,USBLC6-2P6,C15999
Y2,OSC_CSTNE16M0V530000R0,1,16MHz,C341521

## KiCad design 3kg/Ferrarii-2026/Control_Board/Control_Board.kicad_pcb

Parts:
A1: TEENSY_4.1; TEENSY_LONG_EXT
BT1: +12V; AMASS_XT30U-M_1x02_P5.0mm_Vertical
D1, D2, D3, D4, D5, D6, D7, D8, D10, D11, D12, D13: LED_1206_3216Metric
J1: Left Signal Bus; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical
J2: Start Module; TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
J3: Optional Back Diffusion; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J4: Right Signal Bus; JST_PH_B10B-PH-K_1x10_P2.00mm_Vertical
J6: Left Encoder; PinHeader_1x04_P2.54mm_Vertical_SMD_Pin1Left
J7: Right Encoder; PinHeader_1x04_P2.54mm_Vertical
J8: Motor Control Pins; PinHeader_2x05_P2.54mm_Vertical
J9: BLTP1; PinHeader_1x01_P1.27mm_Vertical
J10: BLTP2; PinHeader_1x01_P1.27mm_Vertical
J11: TLTP1; PinHeader_1x01_P1.27mm_Vertical
J12: TLTP2; PinHeader_1x01_P1.27mm_Vertical
J13: TRTP2; PinHeader_1x01_P1.27mm_Vertical
J14: TRTP1; PinHeader_1x01_P1.27mm_Vertical
J15: BRTP2; PinHeader_1x01_P1.27mm_Vertical
J16: BRTP1; PinHeader_1x01_P1.27mm_Vertical
J17: 3.3VTP; PinHeader_1x01_P1.27mm_Vertical
J18: 5VTP; PinHeader_1x01_P1.27mm_Vertical
J19: BMON_TP; PinHeader_1x01_P1.27mm_Vertical
J20: 12V TP; PinHeader_1x01_P1.27mm_Vertical
J21: 12VTP; PinHeader_1x01_P1.27mm_Vertical
J22: B1; PinHeader_1x01_P1.27mm_Vertical
J23: B2; PinHeader_1x01_P1.27mm_Vertical
J24: B_PWM; PinHeader_1x01_P1.27mm_Vertical
J25: A_PWM; PinHeader_1x01_P1.27mm_Vertical
J26: A1; PinHeader_1x01_P1.27mm_Vertical
J27: A2; PinHeader_1x01_P1.27mm_Vertical
J28: GND_TP; PinHeader_1x01_P1.27mm_Vertical
LOW_BAT1: LED_1206_3216Metric
MODE_SEL1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W7.62mm_P2.54mm_LowProfile
R1, R4, R6, R8, R13, R14, R15, R16, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27: 10K; R_1206_3216Metric
R2, R3, R5, R7, R9, R10, R11, R12, R17: 3.9K; R_1206_3216Metric
R28, R42, R43, R44, R45, R46: 2.2K; R_1206_3216Metric
R29, R30, R31, R32, R33, R34, R35, R38, R40: 1K; R_1206_3216Metric
R36, R37, R39, R41: 2K; R_1206_3216Metric
SW1, SW2: BTN1; SW_PUSH_6mm_H5mm
U1: DM-OLED096-636; MODULE_DM-OLED096-636; PARTREV 2018-09-10
U2: 1101M2S3CQE2
U3: TSR1-2450E; Converter_DCDC_TRACO_TSR1-xxxxE_THT

Connections:
+3.3V: A1.3V3 (3.3V), A1.3V3@2 (3.3V), A1.3V3@3 (3.3V), J2.1, J17.1, R42.2, R43.2, R44.1, R45.1, R46.1, U1.2 (VCC_IN)
+5V: A1.VIN, J6.2, J7.2, J8.5, J18.1, U3.3 (Vout)
+12V: J1.9, J3.1, J4.9, J21.1, U2.1, U3.1 (Vin)
+12V_BAT: BT1.1 (+), J20.1, R27.2, U2.2
+12V_BAT_MON: A1.D23 (A9), J19.1, R27.1, R28.2
BL_LN_1: A1.D38 (A14), J1.8, J9.1
BL_LN_2: A1.D39 (A15), J1.7, J10.1
BR_LN_1: A1.D24 (A10), J4.8, J16.1
BR_LN_2: A1.D25 (A11), J4.7, J15.1
BTN_1: A1.D21 (A7), SW1.2
BTN_2: A1.D22 (A8), SW2.2
Back Diffusion: J4.4, R14.1, R23.1
Back Diffusion MCU: A1.D31, R10.1, R14.2, R17.1, R18.2
DIP_1: A1.D3, MODE_SEL1.1, R44.2
DIP_2: A1.D4, MODE_SEL1.2, R45.2
DIP_3: A1.D5, MODE_SEL1.3, R46.2
Front Diffusion: J1.4, R1.1, R19.1
Front Diffusion MCU: A1.D33, R1.2, R2.1
GND: A1.AGND/GND (GND), A1.GND, A1.GND@2 (GND), BT1.2 (-), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), J1.10, J2.2, J3.3, J4.10, J6.4, J7.4, J8.1, J28.1, LOW_BAT1.1 (K), MODE_SEL1.4, MODE_SEL1.5, MODE_SEL1.6, R2.2, R3.2, R5.2, R7.2, R9.2, R10.2, R11.2, R12.2, R17.2, R28.1, R36.2, R37.2, R39.2, R41.2, SW1.1, SW2.1, U1.1 (GND), U3.2 (GND)
LED_1: A1.D20 (A6), R30.1
LED_2: A1.D15 (A1), R31.1
LED_3: A1.D14 (A0), R32.1
LED_4: A1.D17 (A3), R33.1
LOW_BAT: A1.D2, R29.1
L_Diffusion_30: J1.3, R4.1, R20.1
L_Diffusion_30_MCU: A1.D34, R3.1, R4.2
L_Diffusion_60: J1.2, R6.1, R21.1
L_Diffusion_60_MCU: A1.D35, R5.1, R6.2
L_Diffusion_90: J1.1, R8.1, R22.1
L_Diffusion_90_MCU: A1.D36, R7.1, R8.2
L_EN_A: A1.D16 (A2), R34.2, R37.1
L_EN_B: A1.D37, R35.2, R36.1
MOTOR_A_IN1: A1.D9, J8.3, J27.1
MOTOR_A_IN2: A1.D11 ((SDO)D11), J8.2, J26.1
MOTOR_A_PWM: A1.D7, J8.4, J25.1
MOTOR_B_IN1: A1.D10 ((CS)D10), J8.8, J22.1
MOTOR_B_IN2: A1.D12 ((SDI)D12), J8.7, J23.1
MOTOR_B_PWM: A1.D8, J8.9, J24.1
unnamed: D1.2 (A), R19.2
unnamed: D2.2 (A), R20.2
unnamed: D3.2 (A), R21.2
unnamed: D4.2 (A), R22.2
unnamed: D5.2 (A), R23.2
unnamed: D6.2 (A), R24.2
unnamed: D7.2 (A), R25.2
unnamed: D8.2 (A), R26.2
unnamed: D10.2 (A), R30.2
unnamed: D11.2 (A), R31.2
unnamed: D12.2 (A), R32.2
unnamed: D13.2 (A), R33.2
unnamed: J6.1, R34.1
unnamed: J6.3, R35.1
unnamed: J7.1, R40.1
unnamed: J7.3, R38.1
unnamed: LOW_BAT1.2 (A), R29.2
OLED_SCL: A1.D19 (A5), R42.1, U1.3 (SCL)
OLED_SDA: A1.D18 (A4), R43.1, U1.4 (SDA)
OPT_Back Diffusion: J3.2, R18.1
R_Diffusion_30: J4.3, R15.1, R24.1
R_Diffusion_30_MCU: A1.D30, R11.1, R15.2
R_Diffusion_60: J4.2, R16.1, R25.1
R_Diffusion_60_MCU: A1.D29, R12.1, R16.2
R_Diffusion_90: J4.1, R13.1, R26.1
R_Diffusion_90_MCU: A1.D28, R9.1, R13.2
R_EN_A: A1.D1 ((CTX1)D1), R40.2, R41.1
R_EN_B: A1.D0 ((CRX1)D0), R38.2, R39.1
Start_Module_Signal: A1.D6, J2.3
TL_LN_1: A1.D40 (A16), J1.6, J11.1
TL_LN_2: A1.D41 (A17), J1.5, J12.1
TR_LN_1: A1.D26 (A12), J4.6, J14.1
TR_LN_2: A1.D27 (A13), J4.5, J13.1
ULCD RST: A1.D13 ((CLK)D13)

Notes on the sheet:
Encoders
Fuse??
Ferrarii Control Board
