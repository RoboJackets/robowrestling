File: 500g/Therap-i/Schematic/Schematic.kicad_sch (KiCad schematic)
At the start: 13 parts, among them IC1 TC78H653FTG,EL, U1 Teensy4.1, U2 IFX27001TFV50, U3 IFX27001TFV50

Commit message: changed schematic
Parts:
- JS15878, JS200XF1, JS200XF2, JS200XF3, JS200XF5, ML2Line2, ML2Line3: value (none) -> ~
Connections:
- net +5V: now also JS15878. (Signal)
- net GND: now also JS15878. (Signal)
- net ST1: now reaches U1.8 (6_OUT1D)
- net ST1: now also JS15878. (Signal)
Other:
- moved on the sheet: JS15878, U2, U3
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 104.14 63.5) (xy 109.22 63.5))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 39.37 181.61) (xy 39.37 187.96))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 71.12 39.37) (xy 71.12 41.91))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 31.75 181.61) (xy 31.75 184.15))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 55.88 90.17) (xy 55.88 95.25))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 35.56 181.61) (xy 35.56 186.69))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 55.88 41.91) (xy 55.88 39.37))
     (stroke (width 0) (type default))
@@
   )
   (bus (pts (xy 177.8 109.22) (xy 281.94 109.22))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 39.37 187.96) (xy 43.18 187.96))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 4 4)) (justify left bottom))
   )
+  (global_label "ST1" (shape input) (at 104.14 63.5 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 97.7682 63.5 0)
+      (effects (font (size 1.27 1.27)) (justify right) hide)
+    )
+  )
   (global_label "IR3" (shape input) (at 104.14 53.34 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
@@
     (effects (font (size 1.27 1.27)) (justify right))
     (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 260.35 53.0595 90)
+      (effects (font (size 1.27 1.27)) (justify right) hide)
+    )
+  )
+  (global_label "ST1" (shape input) (at 31.75 184.15 270) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 31.75 190.5218 90)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Regulator_Linear:IFX27001TFV50") (at 199.39 82.55 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U2" (at 199.39 74.93 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "IFX27001TFV50" (at 199.39 77.47 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Package_TO_SOT_SMD:TO-252-3_TabPin2" (at 199.39 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://static6.arrow.com/aropdfconversion/dc75757ae45a88e5f69bdce3f2a651a5fe0ca07d/ifx27001_ds_10.pdf" (at 199.39 83.82 0)
+  (symbol (lib_id "Regulator_Linear:IFX27001TFV50") (at 205.74 86.36 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U2" (at 205.74 78.74 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "IFX27001TFV50" (at 205.74 81.28 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Package_TO_SOT_SMD:TO-252-3_TabPin2" (at 205.74 87.63 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://static6.arrow.com/aropdfconversion/dc75757ae45a88e5f69bdce3f2a651a5fe0ca07d/ifx27001_ds_10.pdf" (at 205.74 87.63 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 35.56 125.73 0)
+    (property "Value" "~" (at 35.56 125.73 0)
       (effects (font (size 1.27 1.27)))
     )
@@
         (path "/91e90b3f-7b4c-476f-99fe-bef9ebae8203"
           (reference "ML2Line2") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "power:+5V") (at 43.18 187.96 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR018" (at 39.37 187.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (at 46.99 187.96 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 43.18 187.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 43.18 187.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "Schematic"
+        (path "/91e90b3f-7b4c-476f-99fe-bef9ebae8203"
+          (reference "#PWR018") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "Regulator_Linear:IFX27001TFV50") (at 224.79 82.55 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U3" (at 224.79 74.93 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "IFX27001TFV50" (at 224.79 77.47 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Package_TO_SOT_SMD:TO-252-3_TabPin2" (at 224.79 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://static6.arrow.com/aropdfconversion/dc75757ae45a88e5f69bdce3f2a651a5fe0ca07d/ifx27001_ds_10.pdf" (at 224.79 83.82 0)
+  (symbol (lib_id "Regulator_Linear:IFX27001TFV50") (at 247.65 87.63 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U3" (at 247.65 80.01 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "IFX27001TFV50" (at 247.65 82.55 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Package_TO_SOT_SMD:TO-252-3_TabPin2" (at 247.65 88.9 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://static6.arrow.com/aropdfconversion/dc75757ae45a88e5f69bdce3f2a651a5fe0ca07d/ifx27001_ds_10.pdf" (at 247.65 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 264.16 33.02 0)
+    (property "Value" "~" (at 264.16 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 238.76 33.02 0)
+    (property "Value" "~" (at 238.76 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/91e90b3f-7b4c-476f-99fe-bef9ebae8203"
           (reference "JS200XF2") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "power:GND") (at 35.56 186.69 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR019" (at 35.56 193.04 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 35.56 191.77 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 35.56 186.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 35.56 186.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "Schematic"
+        (path "/91e90b3f-7b4c-476f-99fe-bef9ebae8203"
+          (reference "#PWR019") (unit 1)
         )
       )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 71.12 127 0)
+    (property "Value" "~" (at 71.12 127 0)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 213.36 33.02 0)
+    (property "Value" "~" (at 213.36 33.02 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Start_Module:JS15878") (at 31.75 167.64 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "JS15878" (at 39.37 173.355 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "" (at 39.37 175.895 0)
+  (symbol (lib_id "Start_Module:JS15878") (at 35.56 166.37 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "JS15878" (at 43.18 172.085 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "~" (at 43.18 174.625 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "" (at 31.75 167.64 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 31.75 167.64 0)
+    (property "Footprint" "" (at 35.56 166.37 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 35.56 166.37 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "" (at 208.28 38.1 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Value" "~" (at 208.28 38.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: voltage regulator and battery
Parts:
- added C3, C5: 100nF, symbol Device:C
- added C4, C6: 10µF, symbol Device:C
- added D1, D2: D, symbol Device:D
- added OVI2: ~, symbol power:OVI
- U2, U3: value IFX27001TFV50 -> IFX27001TFV
Connections:
- net +5V: now also U2.2 (Q), U3.2 (Q), C4.1, C6.1
- net GND: now also U2.1 (GND), U3.1 (GND), C3.2, C4.2, C5.2, C6.2, OVI2. (GND)
- net at U2.3 (I): now also C3.1, D1.1 (K)
- net at U3.3 (I): now also C5.1, D2.1 (K)
- new net +12V: D1.2 (A), D2.2 (A), OVI2. (GND)
Other:
- note added: "Power"
- moved on the sheet: U2
