File: 500g/Therap-i/Schematic/Schematic.kicad_sch (KiCad schematic)
At the start: 20 parts, among them IC1 TC78H653FTG,EL, U1 Teensy4.1, U2 IFX27001TFV, U3 IFX27001TFV

Commit message: Fixed motor driver
Parts:
- removed C1, C2: 0.1uF, symbol Device:C
- removed IC1: TC78H653FTG,EL, QFN50P300X300X90-17N, symbol TC78H653FTG_EL:TC78H653FTG,EL
- added BDC1, BDC2: ~, symbol Motor:BDC1
- added C7, C8: 10uF, symbol Device:C
- added R1, R4: 10kΩ, symbol Device:R_US
- added R2, R5: 2.87Ω, symbol Device:R_US
- added R3, R6: 0.4Ω, symbol Device:R_US
- added U4, U5: DRV8832DGQR, DGQ10_2P18X1P72, symbol DRV8832:DRV8832DGQR
Connections:
- net GND: now also C7.2, C8.2, R1.2, R3.1, R4.2, R6.1, U4.11 (EPAD), U4.5 (GND), U5.11 (EPAD), U5.5 (GND)
- net BDC12: now reaches U1.10 (8_TX2_IN1)
- net BDC12: now also U5.10 (IN2)
- net BDC21: now reaches U1.11 (9_OUT1C)
- net BDC21: now also U4.9 (IN1)
- net BDC22: now reaches U1.12 (10_CS_MQSR)
- net BDC22: now also U4.10 (IN2)
- net BDC11: now reaches U1.9 (7_RX2_OUT1A)
- net BDC11: now also U5.9 (IN1)
- new net: BDC1. (2), U5.1 (OUT2)
- new net: BDC1. (2), U5.3 (OUT1)
- new net: R4.1, R5.2, U4.7 (VSET)
- new net: R5.1, U4.8 (VREF)
- new net: BDC2. (2), R6.2, U4.1 (OUT2), U4.2 (ISENSE)
- new net: BDC2. (2), U4.3 (OUT1)
- new net: R3.2, U5.2 (ISENSE)
- new net: R1.1, R2.2, U5.7 (VSET)
- new net: R2.1, U5.8 (VREF)
- new net +6V: C7.1, C8.1, U4.4 (VCC), U5.4 (VCC)
Other:
- moved on the sheet: ML2Line2, U1
