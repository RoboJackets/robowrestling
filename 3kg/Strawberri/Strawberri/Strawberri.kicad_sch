File: 3kg/Strawberri/Strawberri/Strawberri.kicad_sch (KiCad schematic)
At the start: 4 parts, among them J1 Conn_01x03_Pin, J7 Battery, SW1 SW_Nidec_CAS-120A1, U1 DEV-16771

Commit message: rawr
Parts:
- removed SW1: SW_Nidec_CAS-120A1, Button_Switch_SMD:Nidec_Copal_CAS-120A, symbol Switch:SW_Nidec_CAS-120A1
- added C1, C10, C2, C3, C4, C5, C6, C7, C8, C9: C, Capacitor_SMD:CP_Elec_3x5.3, symbol Device:C
- added D1, D2, D3, D4, D5, D6: LED, LED_SMD:LED-APA102-2020, symbol Device:LED
- added F1: Fuse, Fuse:Fuse_1206_3216Metric, symbol Device:Fuse
- added J10, J11, J12, J2, J3, J4, J5, J6, J8, J9: Screw_Terminal_01x03, TerminalBlock:TerminalBlock_Altech_AK300-2_P5.00mm, symbol Connector:Screw_Terminal_01x03
- added R1, R10, R12, R4, R6, R8: R_Small_US, Resistor_SMD:R_0201_0603Metric_Pad0.64x0.40mm_HandSolder, symbol Device:R_Small_US
- added R11, R2, R3, R5, R7, R9: R_US, Resistor_SMD:R_0201_0603Metric_Pad0.64x0.40mm_HandSolder, symbol Device:R_US
- added SW1: SW_SPDT, pleseowrk:switch, symbol Switch:SW_SPDT
- added U2, U3, U4, U5, U6, U7: SFH617A-3, Package_DIP:DIP-4_W7.62mm, symbol Isolator:SFH617A-3
- J1: footprint (none) -> Connector:CUI_PD-30S
- U1: footprint DEV-16771:MODULE_DEV-16771 -> teensy:MODULE_DEV-16771
Connections:
- net dis1: now reaches U1.14 (A0)
- net dis1: now also R1.1, U2.3
- net dis2: now reaches U1.15 (A1)
- net dis2: now also R6.1, U4.3
- net dis3: now reaches U1.16 (A2)
- net dis3: now also R10.1, U6.3
- net dis4: now reaches U1.17 (A3)
- net dis4: now also R4.1, U3.3
- net dis5: now reaches U1.18 (A4)
- net dis5: now also R8.1, U5.3
- net dis6: now reaches U1.19 (A5)
- net dis6: now also R12.1, U7.3
- net GND: now reaches J7.1 (Pin_1)
- net GND: now also C1.2, C10.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.1, C9.1, J10.1 (Pin_1), J11.1 (Pin_1)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
- net at J7.2 (Pin_2): now also SW1.2 (B)
- new net: D2.2 (A), R3.2
- new net: D4.2 (A), R7.2
- new net: D4.1 (K), U5.1
- new net: D6.1 (K), U7.1
- new net: F1.1, SW1.1 (A)
- new net: D5.1 (K), U6.1
- new net: D5.2 (A), R9.2
- new net: D2.1 (K), U3.1
- new net: D6.2 (A), R11.2
- new net: D3.2 (A), R5.2
- new net: D3.1 (K), U4.1
- new net: D1.1 (K), U2.1
- new net: D1.2 (A), R2.2
- new net +12V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, F1.2, J2.1 (Pin_1), J3.1 (Pin_1), J4.1 (Pin_1), J5.1 (Pin_1), J6.1 (Pin_1)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
- new net +3.3V: C10.2, C7.2, C8.2, C9.2, J10.2 (Pin_2), J11.2 (Pin_2), J12.2 (Pin_2), J9.2 (Pin_2), U2.4, U3.4, U4.4, U5.4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
- new net LN1: J9.3 (Pin_3)
- new net LN2: J10.3 (Pin_3)
- new net LN3: J11.3 (Pin_3)
- new net LN4: J12.3 (Pin_3)
- new net OM1: J2.3 (Pin_3), R2.1
- new net OM2: J3.3 (Pin_3), R5.1
- new net OM3: J4.3 (Pin_3), R3.1
- new net OM4: J5.3 (Pin_3), R7.1
- new net OM5: J6.3 (Pin_3), R11.1, R9.1
- new net OM6: J8.3 (Pin_3)
- no-connect marks 0 -> 1
Other:
- note added: "note to self figure out capacitor values"
- moved on the sheet: J7

Commit message: changes
Parts:
- added C11, C12, C17: C, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added C13, C14: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- added C15: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added C16: 10 uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added H1, H2: MountingHole, MountingHole:MountingHole_2.5mm, symbol Mechanical:MountingHole
- added J13, J14: Screw_Terminal_01x03, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector:Screw_Terminal_01x03
- added J15: Conn_02x05_Odd_Even, Connector:Tag-Connect_TC2050-IDC-FP_2x05_P1.27mm_Vertical, symbol Connector_Generic:Conn_02x05_Odd_Even
- added U8: R-78K5.0-0.5 (vr 3.3v), pleseowrk:voltageregulator, symbol 2024-11-08_01-03-56:R-78K5.0-0.5
- added U9: R-78K5.0-0.5 (vr 5v), pleseowrk:voltageregulator, symbol 2024-11-08_01-03-56:R-78K5.0-0.5
- C1, C10, C2, C3, C4, C5, C6, C7, C8, C9: footprint Capacitor_SMD:CP_Elec_3x5.3 -> Capacitor_SMD:C_0805_2012Metric
- D1, D2, D3, D4, D5, D6: footprint LED_SMD:LED-APA102-2020 -> LED_SMD:LED_1206_3216Metric
- J1: footprint Connector:CUI_PD-30S -> TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
- J10, J11, J12, J2, J3, J4, J5, J6, J8, J9: footprint TerminalBlock:TerminalBlock_Altech_AK300-2_P5.00mm -> TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal
- R1: footprint Resistor_SMD:R_0201_0603Metric_Pad0.64x0.40mm_HandSolder -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- R10, R11, R12, R2, R3, R4, R5, R6, R7, R8, R9: footprint Resistor_SMD:R_0201_0603Metric_Pad0.64x0.40mm_HandSolder -> Resistor_SMD:R_0805_2012Metric
Connections:
- net +12V: now also C13.1, C14.1, U8.1 (+VIN), U9.1 (+VIN)
- net +3.3V: now also J1.3 (Pin_3), U1.3.3V_1 (3.3V), U1.3.3V_2 (3.3V), U1.3.3V_3 (3.3V), C11.2, C12.2, C15.1, C17.1, J13.2 (Pin_2), J14.2 (Pin_2), U8.3 (+VOUT)
- net GND: now also J1.2 (Pin_2), U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U1.GND4 (GND), U1.GND5 (GND), U1.USB_GND1 (USB_GND), U1.USB_GND2 (USB_GND), C11.1, C12.1, C13.2, C14.2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
- net LN1: now also U1.41 (A17)
- net LN2: now also U1.40 (A16)
- net LN3: now also U1.39 (A15)
- net LN4: now also U1.38 (A14)
- net OM5: no longer R11.1
- net OM6: now also R11.1
- net dis3: now also R4.1, U1.24 (A10), U3.3; no longer R10.1, U1.16 (A2), U6.3
- net dis4: now also R8.1, U1.25 (A11), U5.3; no longer R4.1, U1.17 (A3), U3.3
- net dis5: now also R10.1, U1.26 (A12), U6.3; no longer R8.1, U1.18 (A4), U5.3
- net dis6: now also U1.27 (A13); no longer U1.19 (A5)
- net start: now reaches J1.1 (Pin_1)
- net start: now also U1.13 (SCK)
- net BDC1: now reaches U1.11 (MOSI)
- net BDC1: now also J15.5 (Pin_5)
- net BDC11: now reaches U1.12 (MISO)
- net BDC11: now also J15.3 (Pin_3)
- net Dis7: now reaches U1.20 (A6)
- net Dis7: now also J13.3 (Pin_3)
- net dis8: now reaches U1.21 (A7)
- net dis8: now also J14.3 (Pin_3)
- net BDC22: now reaches U1.36 (CS2)
- net BDC22: now also J15.6 (Pin_6)
- net BDC2: now reaches U1.37 (CS3)
- net BDC2: now also J15.4 (Pin_4)
- net +5V: now reaches U1.5V
- net +5V: now also U1.VIN, C16.1, J15.9 (Pin_9), U9.3 (+VOUT)
- new net PWMA: J15.7 (Pin_7)
- new net PWMB: J15.8 (Pin_8)
Other:
- note added: "voltage regulator"

Commit message: reorganized schematic
TODO:
- add servos
- change to jst
- add imu
- react to joes messages
Parts:
- removed C13: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C_Small
- removed C15: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed U8: R-78K5.0-0.5 (vr 3.3v), pleseowrk:voltageregulator, symbol 2024-11-08_01-03-56:R-78K5.0-0.5
- added C18, C19, C20, C21, C22: C, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added D7: LED, LED_SMD:LED_1206_3216Metric, symbol Device:LED
- added J16, J17, J18, J19, J20: Screw_Terminal_01x03, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector:Screw_Terminal_01x03
- added R13: R_US, Resistor_SMD:R_0805_2012Metric, symbol Device:R_US
- added R14: R_Small_US, Resistor_SMD:R_0805_2012Metric, symbol Device:R_Small_US
- added U10: SFH617A-3, Package_DIP:DIP-4_W7.62mm, symbol Isolator:SFH617A-3
Connections:
- net +12V: now also C18.1, J16.1 (Pin_1)
- net +3.3V: now also U10.4
- net Dis7: no longer J13.3 (Pin_3)
- net GND: now also C18.2, C19.1, C20.1, C21.1, C22.1, J16.2 (Pin_2), J17.1 (Pin_1), J18.1 (Pin_1), J19.1 (Pin_1), J20.1 (Pin_1), R14.2, U10.2
- net OM6: now also R13.1
- new net: C21.2, J19.2 (Pin_2)
- new net: C20.2, J18.2 (Pin_2)
- new net: D7.1 (K), U10.1
- new net: D7.2 (A), R13.2
- new net: C19.2, J17.2 (Pin_2)
- new net: C22.2, J20.2 (Pin_2)
- new net OM7: J16.3 (Pin_3)
- new net a1: J13.3 (Pin_3)
- new net dis7: R14.1, U10.3
- new net l1: J17.3 (Pin_3)
- new net l2: J18.3 (Pin_3)
- new net l3: J19.3 (Pin_3)
- new net l4: J20.3 (Pin_3)
- no-connect marks 1 -> 39
Other:
- note added: "1 analog sensor"
- note added: "4 line sensors"
- note added: "7 omron sensors"
- note added: "add imu connector switch to jsts double check number of sensors"
- note added: "line sensors (4)"
- note removed: "note to self figure out capacitor values"
- moved on the sheet: C1, C10, C11, C12, C14, C16, C17, C2, C3, C4, C5, C6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

Commit message: parts added
to do:
switch to jsts
double check number of sensors
add labels to microcontroller
where tf is the motor driver datasheet???
figure out capacitor values
check omron symbol + footprint
Parts:
- removed C10, C17, C7, C8, C9: C, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed J1: Conn_01x03_Pin, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector:Conn_01x03_Pin
- removed J10, J11, J12, J9: Screw_Terminal_01x03, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector:Screw_Terminal_01x03
- added C13: C, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added J1: Screw_Terminal_01x08, symbol Connector:Screw_Terminal_01x08
- added J21: Screw_Terminal_01x03, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector:Screw_Terminal_01x03
- added SW2: SW_DIP_x03, symbol Switch:SW_DIP_x03
Connections:
- net Dis7 is gone; now on net dis7: U1.20 (A6)
- net LN1 is gone; now on net l1: U1.41 (A17)
- net LN2 is gone; now on net l2: U1.40 (A16)
- net LN3 is gone; now on net l3: U1.39 (A15)
- net LN4 is gone; now on net l4: U1.38 (A14)
- net +3.3V: no longer C11.2, C12.2, J13.2 (Pin_2), J14.2 (Pin_2)
- net +5V: now also C11.2, C12.2, C19.2, C20.2, C21.2, C22.2, J13.2 (Pin_2), J14.2 (Pin_2), J17.2 (Pin_2), J18.2 (Pin_2), J19.2 (Pin_2), J20.2 (Pin_2)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
- net GND: now also C13.1, J1.2 (Pin_2), J21.1 (Pin_1)
- net OM6: no longer R13.1
- net OM7: now also R13.1
- net dis8: no longer J14.3 (Pin_3)
- new net ado: J1.7 (Pin_7)
- new net int: J1.8 (Pin_8)
- new net scl: J1.3 (Pin_3)
- new net sda: J1.4 (Pin_4)
- new net servo1: J14.3 (Pin_3)
- new net servo2: J21.3 (Pin_3)
- new net switch1: SW2.6
- new net switch2: SW2.5
- new net switch3: SW2.4
- new net xcl: J1.6 (Pin_6)
- new net xda: J1.5 (Pin_5)
Other:
- note added: "2 servo motors (should be PWM)"
- note added: "3 dip switches"
- note added: "battery"
- note added: "imu"
- note added: "motor driver?"
- note added: "to do: switch to jsts double check number of sensors add labels to microcontroller where tf is the motor driver datasheet figure out capacitor values check omron symbol + footprint"
- note removed: "add imu connector switch to jsts double check number of sensors"
- note removed: "line sensors (4)"
- moved on the sheet: C1, C11, C14, C16, C18, C19, C2, C20, C21, C22, C3, C4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

Commit message: did some todos
yeah
Parts:
- removed U10, U2, U3, U4, U5, U6, U7: SFH617A-3, Package_DIP:DIP-4_W7.62mm, symbol Isolator:SFH617A-3
- added J9: Conn_01x03, TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal, symbol Connector_Generic:Conn_01x03
- added octo1, octo2, octo3, octo4, octo5, octo6, octo7: PC817, Connector_Molex:Molex_Pico-EZmate_Slim_202656-0021_1x02-1MP_P1.20mm_Vertical, symbol 2026-01-23_00-22-03:PC817
- added start1: .1 uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- C1, C18, C2, C3, C4, C5, C6: value C -> .1 µF
- C11, C19, C20, C21, C22: value C -> 10 µF
- C12, C13: value C -> 1000 µF
- J1: footprint (none) -> Connector_JST:JST_PH_B8B-PH-K_1x08_P2.00mm_Vertical
- J13, J17, J18, J19, J20: footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- J7: footprint Connector_AMASS:AMASS_XT30U-F_1x02_P5.0mm_Vertical -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- R10, R12, R14, R4, R6, R8: footprint Resistor_SMD:R_0805_2012Metric -> Resistor_SMD:R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
- SW2: footprint (none) -> switch:SW_219-3LPSTR
- om1: renamed from J2; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om2: renamed from J3; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om3: renamed from J4; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om4: renamed from J5; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om5: renamed from J6; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om6: renamed from J8; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
- om7: renamed from J16; footprint TerminalBlock:TerminalBlock_Xinya_XY308-2.54-3P_1x03_P2.54mm_Horizontal -> Connector_JST:JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
Connections:
- net +3.3V: now also J9.2 (Pin_2), octo1.4, octo2.4, octo3.4, octo4.4, octo5.4, octo6.4, octo7.4, start1.2
- net GND: now also J9.3 (Pin_3), octo1.2, octo2.2, octo3.2, octo4.2, octo5.2, octo6.2, octo7.2, start1.1
- net OM2: now also R3.1; no longer R5.1
- net OM3: now also R5.1; no longer R3.1
- net dis1: now also octo1.3
- net dis2: now also R4.1, octo2.3; no longer R6.1
- net dis3: now also R6.1, octo3.3; no longer R4.1
- net dis4: now also octo4.3
- net dis5: now also octo5.3
- net dis6: now also octo6.3
- net dis7: now also octo7.3
- net start: now also J9.1 (Pin_1)
- net at D4.1 (K): now also octo4.1
- net at D6.1 (K): now also octo6.1
- net at D7.1 (K): now also octo7.1
- net at D5.1 (K): now also octo5.1
- net at D2.1 (K): now also octo2.1
- net at D3.1 (K): now also octo3.1
- net at D1.1 (K): now also octo1.1
Other:
- note added: "to do: add labels to microcontroller"
- note removed: "to do: switch to jsts double check number of sensors add labels to microcontroller where tf is the motor driver datasheet figure out capacitor values check omron symbol + footprint"
- moved on the sheet: C1, C11, C12, C13, C14, C16, C18, C19, C2, C20, C21, C22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
